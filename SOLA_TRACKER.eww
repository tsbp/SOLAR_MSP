<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SOLA_TRACKER.ewp</path>
  </project>
  <batchBuild/>
</workspace>


